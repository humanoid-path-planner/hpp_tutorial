Commit message: Update cup model (add two handles and a mass)

File: urdf/cup.urdf (robot description, URDF)
Before this commit: robot cup, 1 links, 0 joints
Links:
- link base_link: mass None -> 1.2
